# Keil uVision project 407.uvprojx, settings and files
target Target_1 (ARM-ADS)
  device: STM32F407VETx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.3.1.1-dev
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: 407
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER.STM32F4XX
  c include: .\CMSIS;\CMSIS\Device\ST\STM32F4xx\Include;\CMSIS\Device\ST\STM32F4xx\Source;\STM32F4xx_StdPeriph_Driver;\STM32F4xx_StdPeriph_Driver\inc;\STM32F4xx_StdPeriph_Driver\src;\Main
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group Source Group 1
    ./: main.c port_ini.c
    ./STM32F4xx_StdPeriph_Driver/src/: stm32f4xx_gpio.c stm32f4xx_rcc.c
software components: CMSIS:CORE 6.1.0, Device:CubeMX 1.0.0
